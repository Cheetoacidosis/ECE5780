# Keil uVision project Lab1-5780.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Lab1-5780
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: main.c LEDtoggle.c LEDtoggle.h data.c data.h censor.c censor.h my_queues.c my_queues.h USART.c USART_IRQ.c USART.h
    ./: output_file
software components: CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, Device:Startup 1.3.2
